# Keil uVision project velocity_keyboard.uvprojx, settings and files
target Velocity Keyboard - DAPLink Download (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(64000000) ELITTLE
  output: velocity_keyboard +hex
  BeforeMake: powershell.exe -NoProfile -ExecutionPolicy Bypass -File ".\refresh_image.ps1"
  AfterMake: powershell.exe -NoProfile -ExecutionPolicy Bypass -File ".\verify_output.ps1"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\qualified_image.sct
  link misc: --entry=Reset_Handler --no_scanlib --no_remove
  group Qualified firmware image
    ./: image_container.c
